# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 wLevel=4
  c define: USE_STDPERIPH_DRIVER
  c include: .\Startup;.\User;.\Libraries;.\System;.\Hardware
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Libraries
    ./Libraries/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group Startup
    ./Startup/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group System
    ./System/: Delay.c Delay.h Timer.c Timer.h pid.c pid.h myMath.c myMath.h imu.c imu.h Kalman.c Kalman.h
  group User
    ./User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h main.c Data.c Data.h Control.c Control.h Receive.c Receive.h
  group Hardware
    ./Hardware/: Motor.c Motor.h MPU6050.c MPU6050.h MPU6050_Reg.h Serial.c Serial.h ESP.c ESP.h MyI2C.c MyI2C.h BMP280.c BMP280.h MyI2C_BMP.c MyI2C_BMP.h

# Keil uVision project GUIDemo.uvprojx, settings and files
target MCBSTM32C (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: GUIDemo
  c flags: Optim=4
  c misc: --diag_suppress=1035
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c
  group Documentation
    ./: Abstract.txt
target MCBSTM32C LCD_LG (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: GUIDemo
  c flags: Optim=4
  c misc: --diag_suppress=1035
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS:Keil RTX 4.82.0, Board Support:Joystick 2.0.0, Board Support:Touchscreen 2.0.0, Board Support:emWin LCD 2.0.0, CMSIS Driver:I2C 2.2, CMSIS Driver:SPI 2.2, Device:DMA 1.3, Device:GPIO 1.3, Device:Startup 1.0.0, Graphics:CORE 6.16.3, Graphics:Demo:Automotive 6.16.3, Graphics:Demo:ColorBar 6.16.3, Graphics:Demo:Cursor 6.16.3, Graphics:Demo:Framework 6.16.3, Graphics:Demo:Graph 6.16.3, Graphics:Demo:ListView 6.16.3, Graphics:Demo:Speed 6.16.3, Graphics:Demo:TransparentDialog 6.16.3, Graphics:Display:MCBQVGA_LD 6.16.3, Graphics:Display:MCBQVGA_LG 6.16.3, Graphics:Input Device:Joystick 6.16.3, Graphics:Input Device:Touchscreen 6.16.3

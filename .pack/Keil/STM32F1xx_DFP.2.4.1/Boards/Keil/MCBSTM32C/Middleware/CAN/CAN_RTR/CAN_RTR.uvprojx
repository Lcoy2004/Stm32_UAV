# Keil uVision project CAN_RTR.uvprojx, settings and files
target STM32F107 - Consumer (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CAN_RTR_Consumer
  c flags: Optim=4
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Files
    ./: CAN_RTR_Consumer.c CAN_RTR_Producer.c
  group Documentation
    ./: Abstract.txt
target STM32F107 - Producer (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: CAN_RTR_Producer
  c flags: Optim=4
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 4.2.0, CMSIS:RTOS:Keil RTX 4.79.0, Board Support:Graphic LCD 2.0.0, CMSIS Driver:CAN 1.0, CMSIS Driver:SPI 2.0, Compiler:I/O:STDERR 1.0.0, Compiler:I/O:STDIN 1.0.0, Compiler:I/O:STDOUT 1.0.0, Device:DMA 1.1, Device:GPIO 1.1, Device:Startup 1.0.0
